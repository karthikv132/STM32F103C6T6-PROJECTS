# Keil uVision project 1_DIGIT_INCRE_DECRE_USING_TIMER.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 1_DIGIT_INCRE_DECRE_USING_TIMER +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ./: 1_DIGIT_INCRE_DECRE_USING_TIMER.c
software components: CMSIS:CORE 5.5.0, Device:GPIO 1.3, Device:Startup 1.0.0
